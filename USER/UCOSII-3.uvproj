# Keil uVision project UCOSII-3.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: KLL_CAR_WIFI_V2_1 +hex
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\IIC;..\UCOSII\CONFIG;..\UCOSII\CORE;..\UCOSII\PORT;..\MALLOC;..\HARDWARE\USART2;..\HARDWARE\UART5;..\HARDWARE\POWER;..\HARDWARE\MC323;..\HARDWARE\GPS;..\HARDWARE\Flash;..\STM32F10x_FWLib\inc;..\SYSTEM\analysis;..\SYSTEM\commad;..\HARDWARE\USART3;..\HARDWARE\ADC;..\HARDWARE\WHG;..\HARDWARE\RFID;..\HARDWARE\SPI
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/MC323/: mc323.c
    ../HARDWARE/POWER/: power_drv.c
    ../HARDWARE/USART2/: usart2.c
    ../HARDWARE/Flash/: flash_in.c
    ../HARDWARE/USART3/: usart3.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/WHG/: whg.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/RFID/: rc522.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/analysis/: analysis.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_adc.c stm32f10x_iwdg.c stm32f10x_wwdg.c
  group UCOSII-CORE
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII-PORT
    ../UCOSII/PORT/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group UCOSII-CONFIG
    ../UCOSII/CONFIG/: includes.h os_cfg.h
